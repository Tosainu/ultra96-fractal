#Note: Mention Each package in individual line
#      cascaded representation with line breaks are not valid in this file.
IMAGE_INSTALL_append = " kernel-module-fractal"
IMAGE_INSTALL_append = " fractal-explorer"
