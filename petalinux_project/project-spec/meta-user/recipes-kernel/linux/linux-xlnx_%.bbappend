SRC_URI += "file://user_2019-03-04-04-46-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

